QCOM_DTB_DEFAULT:rubikpi3 = "qcs6490-thundercomm-rubikpi3-qcom-multimedia"
