QCOM_DTB_DEFAULT:rubikpi3 = "qcs6490-thundercomm-rubikpi3-qcom-multimedia"

CORE_IMAGE_BASE_INSTALL:append:rubikpi3 = " chicdk-rubikpi3"
