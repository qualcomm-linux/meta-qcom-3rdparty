FILESEXTRAPATHS:prepend := "${THISDIR}/${MACHINE}:"

SRC_URI:append:qcs6490mio5355a1 = " file://0001-ASoC-qcom-add-Advantech-QCM6490-machine-driver-suppo.patch "

