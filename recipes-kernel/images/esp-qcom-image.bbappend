# Arduino:
## Dtb as part of UKI until the proper edk2 firmware is available
KERNEL_DEVICETREE:uno-q = "${QCOM_DTB_DEFAULT}.dtb"
