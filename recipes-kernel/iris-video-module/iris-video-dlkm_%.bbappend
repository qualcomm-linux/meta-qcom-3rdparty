# This driver is not expected to support/work on agatti (the soc on unoq).
# However, this hash is buildable, which allows maintaining a sane ci.
SRCREV:uno-q  = "02248f4021f7690e675c408b4fd0208ad559a1d5"
PV:uno-q = "1.0.4"
