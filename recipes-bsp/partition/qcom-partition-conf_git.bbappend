FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:uno-q = " file://0001-qrb2210-unoq-update-partitions-based-on-the-edk2-dow.patch"
