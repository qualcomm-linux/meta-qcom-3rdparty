# Inforce / Penguin Edge devkits
PACKAGE_INSTALL += " \
    packagegroup-inforce-ifc6410-firmware \
    packagegroup-inforce-ifc6560-firmware \
    packagegroup-inforce-ifc6560-hexagon-dsp-binaries \
    packagegroup-lantronix-openq-835-hdk-firmware \
    packagegroup-lantronix-openq-835-hdk-hexagon-dsp-binaries \
"
